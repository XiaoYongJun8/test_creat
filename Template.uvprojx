# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --C99
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\beep;.\APP\DMA;.\APP\UART;.\APP\time;.\APP\exti;.\APP\control;.\UCOSSII\Ports;.\UCOSSII\Source;.\UCOSSII\uC-CPU;.\APP\pclink;.\APP\fun;.\APP\RTC;.\APP\usb;.\APP\MX25L;.\APP\rs485;.\APP\CRC16;.\APP\Screen;.\APP\dac;.\APP\ADC;.\APP\iwdg;1;1;1;1;1;1;1;1;1;.\APP\ADS8688
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_adc.c
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c
  group APP
    ./Libraries/CMSIS/: system_stm32f10x.c
    ./APP/usb/: CH374DRV.C
    ./APP/UART/: uart.c
    ./APP/DMA/: dma.c
    ./APP/Screen/: screendriver.c screenshow.c screencore.c
    ./APP/led/: led.c
    ./APP/RTC/: rtc.c
    ./APP/MX25L/: MX25l.c
    ./APP/rs485/: rs485.c
    ./APP/CRC16/: crc16.c
    ./APP/pclink/: pclink.c
    ./APP/dac/: dac8771.c
    ./APP/ADC/: adc.c
    ./APP/exti/: exti.c
    ./APP/iwdg/: iwdg.c
    ./APP/ADS8688/: ADS8688.c
  group Public
    ./Public/: system.c SysTick.c
  group UCOSSII
    ./UCOSSII/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ./UCOSSII/Ports/: os_cpu_c.c os_dbg.c os_cpu.h os_cpu_a.asm
    ./UCOSSII/uC-CPU/: cpu.h cpu_a.asm cpu_core.h cpu_def.h
  group USBLIB
    ./USBLIB/lib/: CH374HFM.LIB
